/*
 * The FairPlay setup handshake some senders insist on before streaming
 * (POST /fp-setup). These are shairport-sync's canned replies
 * (handle_fp_setup in rtsp.c, Copyright (c) Mike Brady 2014--2026, MIT
 * License): no FairPlay is computed, since AirPlay 2 audio is keyed by the
 * pairing, not by this exchange.
 */

#include "airplay/receiver/fp_setup.h"

#include <stdlib.h>
#include <string.h>

static const uint8_t server_fp_reply1[] =
    "\x46\x50\x4c\x59\x03\x01\x02\x00\x00\x00\x00\x82\x02\x00\x0f\x9f\x3f\x9e\x0a"
    "\x25\x21\xdb\xdf\x31\x2a\xb2\xbf\xb2\x9e\x8d\x23\x2b\x63\x76\xa8\xc8\x18\x70"
    "\x1d\x22\xae\x93\xd8\x27\x37\xfe\xaf\x9d\xb4\xfd\xf4\x1c\x2d\xba\x9d\x1f\x49"
    "\xca\xaa\xbf\x65\x91\xac\x1f\x7b\xc6\xf7\xe0\x66\x3d\x21\xaf\xe0\x15\x65\x95"
    "\x3e\xab\x81\xf4\x18\xce\xed\x09\x5a\xdb\x7c\x3d\x0e\x25\x49\x09\xa7\x98\x31"
    "\xd4\x9c\x39\x82\x97\x34\x34\xfa\xcb\x42\xc6\x3a\x1c\xd9\x11\xa6\xfe\x94\x1a"
    "\x8a\x6d\x4a\x74\x3b\x46\xc3\xa7\x64\x9e\x44\xc7\x89\x55\xe4\x9d\x81\x55\x00"
    "\x95\x49\xc4\xe2\xf7\xa3\xf6\xd5\xba";
static const uint8_t server_fp_reply2[] =
    "\x46\x50\x4c\x59\x03\x01\x02\x00\x00\x00\x00\x82\x02\x01\xcf\x32\xa2\x57\x14"
    "\xb2\x52\x4f\x8a\xa0\xad\x7a\xf1\x64\xe3\x7b\xcf\x44\x24\xe2\x00\x04\x7e\xfc"
    "\x0a\xd6\x7a\xfc\xd9\x5d\xed\x1c\x27\x30\xbb\x59\x1b\x96\x2e\xd6\x3a\x9c\x4d"
    "\xed\x88\xba\x8f\xc7\x8d\xe6\x4d\x91\xcc\xfd\x5c\x7b\x56\xda\x88\xe3\x1f\x5c"
    "\xce\xaf\xc7\x43\x19\x95\xa0\x16\x65\xa5\x4e\x19\x39\xd2\x5b\x94\xdb\x64\xb9"
    "\xe4\x5d\x8d\x06\x3e\x1e\x6a\xf0\x7e\x96\x56\x16\x2b\x0e\xfa\x40\x42\x75\xea"
    "\x5a\x44\xd9\x59\x1c\x72\x56\xb9\xfb\xe6\x51\x38\x98\xb8\x02\x27\x72\x19\x88"
    "\x57\x16\x50\x94\x2a\xd9\x46\x68\x8a";
static const uint8_t server_fp_reply3[] =
    "\x46\x50\x4c\x59\x03\x01\x02\x00\x00\x00\x00\x82\x02\x02\xc1\x69\xa3\x52\xee"
    "\xed\x35\xb1\x8c\xdd\x9c\x58\xd6\x4f\x16\xc1\x51\x9a\x89\xeb\x53\x17\xbd\x0d"
    "\x43\x36\xcd\x68\xf6\x38\xff\x9d\x01\x6a\x5b\x52\xb7\xfa\x92\x16\xb2\xb6\x54"
    "\x82\xc7\x84\x44\x11\x81\x21\xa2\xc7\xfe\xd8\x3d\xb7\x11\x9e\x91\x82\xaa\xd7"
    "\xd1\x8c\x70\x63\xe2\xa4\x57\x55\x59\x10\xaf\x9e\x0e\xfc\x76\x34\x7d\x16\x40"
    "\x43\x80\x7f\x58\x1e\xe4\xfb\xe4\x2c\xa9\xde\xdc\x1b\x5e\xb2\xa3\xaa\x3d\x2e"
    "\xcd\x59\xe7\xee\xe7\x0b\x36\x29\xf2\x2a\xfd\x16\x1d\x87\x73\x53\xdd\xb9\x9a"
    "\xdc\x8e\x07\x00\x6e\x56\xf8\x50\xce";
static const uint8_t server_fp_reply4[] =
    "\x46\x50\x4c\x59\x03\x01\x02\x00\x00\x00\x00\x82\x02\x03\x90\x01\xe1\x72\x7e"
    "\x0f\x57\xf9\xf5\x88\x0d\xb1\x04\xa6\x25\x7a\x23\xf5\xcf\xff\x1a\xbb\xe1\xe9"
    "\x30\x45\x25\x1a\xfb\x97\xeb\x9f\xc0\x01\x1e\xbe\x0f\x3a\x81\xdf\x5b\x69\x1d"
    "\x76\xac\xb2\xf7\xa5\xc7\x08\xe3\xd3\x28\xf5\x6b\xb3\x9d\xbd\xe5\xf2\x9c\x8a"
    "\x17\xf4\x81\x48\x7e\x3a\xe8\x63\xc6\x78\x32\x54\x22\xe6\xf7\x8e\x16\x6d\x18"
    "\xaa\x7f\xd6\x36\x25\x8b\xce\x28\x72\x6f\x66\x1f\x73\x88\x93\xce\x44\x31\x1e"
    "\x4b\xe6\xc0\x53\x51\x93\xe5\xef\x72\xe8\x68\x62\x33\x72\x9c\x22\x7d\x82\x0c"
    "\x99\x94\x45\xd8\x92\x46\xc8\xc3\x59";

static const uint8_t server_fp_header[] = "\x46\x50\x4c\x59\x03\x01\x04\x00\x00\x00\x00\x14";

#define VERSION_POS 4
#define TYPE_POS 5
#define SEQ_POS 6
#define MODE_POS 14
#define SETUP_TYPE 1
#define SETUP1_SEQ 1
#define SETUP2_SEQ 3
#define SETUP2_SUFFIX_LEN 20

uint8_t *fp_setup_reply(const uint8_t *req, size_t req_len, size_t *reply_len) {
    if (req_len <= MODE_POS || req[VERSION_POS] != 3 || req[TYPE_POS] != SETUP_TYPE) {
        return NULL;
    }
    // Every array carries a terminating NUL that isn't part of the message.
    if (req[SEQ_POS] == SETUP1_SEQ) {
        static const uint8_t *const replies[] = {server_fp_reply1, server_fp_reply2, server_fp_reply3,
                                                 server_fp_reply4};
        if (req[MODE_POS] > 3) {
            return NULL;
        }
        *reply_len = sizeof(server_fp_reply1) - 1;
        uint8_t *out = malloc(*reply_len);
        if (out) {
            memcpy(out, replies[req[MODE_POS]], *reply_len);
        }
        return out;
    }
    if (req[SEQ_POS] == SETUP2_SEQ && req_len >= SETUP2_SUFFIX_LEN) {
        size_t head = sizeof(server_fp_header) - 1;
        *reply_len = head + SETUP2_SUFFIX_LEN;
        uint8_t *out = malloc(*reply_len);
        if (out) {
            memcpy(out, server_fp_header, head);
            memcpy(out + head, req + req_len - SETUP2_SUFFIX_LEN, SETUP2_SUFFIX_LEN);
        }
        return out;
    }
    return NULL;
}
